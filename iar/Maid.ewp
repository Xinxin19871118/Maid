# IAR project Maid.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\src; ..\freertos; ..\..\..\..\LibRoot\freertos-v821-stm32f4\include; ..\..\..\..\LibRoot\freertos-v821-stm32f4\portable\IAR\ARM_CM4F; ..\..\..\..\LibRoot\freertos-v821-stm32f4\src; ..\..\..\..\LibRoot\stm32f4-lib\src; ..\..\..\..\LibRoot\stm32f4-lib\inc; ..\..\..\..\LibRoot\stm32f4-lib\device-file
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Maid.out
  ILINK.IlinkIcfFile: J:\stm32\stm32F4\Maid\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c stm32f4xx_it.c
    ../../../../LibRoot/stm32f4-lib/iar/Debug/Exe/: stm32f4-lib.a
  group bsp
    ../src/: at24cxx.c Delay.c flash.c Led.c McuTest.c UartConsole.c
  group freertos
    ../freertos/: FreertosUser.c
    ../../../../LibRoot/freertos-v821-stm32f4/iar/Debug/Exe/: lib-freertos-v821-stm32f4.a
